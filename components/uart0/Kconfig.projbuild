## components/uart0/Kconfig.projbuild
```kconfig
menu "uart0"
    config MY_uart0_ENABLE
    bool "Enable my_com"
    default "y"
    endmenu
```
